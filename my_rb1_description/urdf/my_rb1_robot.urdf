Commit message: fix issues

File: my_rb1_description/urdf/my_rb1_robot.urdf (robot description, URDF)
Before this commit: robot rb1_robot, 7 links, 6 joints
Links:
- link base_link: geometry collision cylinder length=0.3 radius=0.25; visual cylinder length=0.3 radius=0.25
